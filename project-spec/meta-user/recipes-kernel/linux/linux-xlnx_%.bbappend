SRC_URI += "file://user_2026-05-16-12-41-00.cfg \
            file://user_2026-05-16-12-47-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

